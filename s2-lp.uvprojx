# Keil uVision project s2-lp.uvprojx, settings and files
target s2-lp-flipper-chat (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: STM32L053R8Hx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: s2-lp-flipper-chat
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=2
  c define: STM32L053xx USE_STM32L0XX_NUCLEO USE_HAL_DRIVER USE_SYSTICK_DELAY
  c misc: --diag_suppress=2548
  c include: .\Drivers\MCU\HAL\inc;.\Drivers\BSP\inc;.\Drivers\Utils\inc;.\Drivers\S2LP_Library\inc;.\Drivers\S2LP_Middleware\inc;.\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Drivers/CMSIS
    ./Drivers/MCU/CMSIS/src/: startup_stm32l053xx.s system_stm32l0xx.c
  group Drivers/BSP
    ./Drivers/BSP/src/: SDK_EVAL_Button.c SDK_EVAL_Com_DMA.c SDK_EVAL_Led.c
  group Drivers/Utils
    ./Drivers/Utils/src/: SDK_UTILS_Timers.c
  group S2LP_Library
    ./Drivers/S2LP_Library/src/: S2LP_Commands.c S2LP_Csma.c S2LP_Fifo.c S2LP_General.c S2LP_Gpio.c S2LP_PacketHandler.c S2LP_PktBasic.c S2LP_PktStack.c S2LP_PktWMbus.c S2LP_Qi.c S2LP_Radio.c S2LP_Timer.c S2LP_Types.c
  group S2LP_Middleware
    ./Drivers/S2LP_Middleware/src/: S2LP_CORE_GPIO.c S2LP_CORE_SPI.c S2LP_AUX_EEPROM.c S2LP_AUX_FEM_AUTO.c S2LP_AUX_TCXO_AUTO.c S2LP_AUX_UTILS.c
  group Source
    ./Source/: ST_Init.c stm32l0xx_it.c s2-lp-flipper-chat.c
  group Drivers/HAL
    ./Drivers/MCU/HAL/src/: stm32l0xx_hal.c stm32l0xx_hal_cortex.c stm32l0xx_hal_dma.c stm32l0xx_hal_gpio.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_spi.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c
software components: CMSIS:CORE 5.6.0
